# Autodesk Inventor assembly: 21.1490 HANDLE ASSY
## iProperties
Created: 2012-03
Part Number: 21.1490 HANDLE ASSY
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
