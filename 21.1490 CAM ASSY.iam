# Autodesk Inventor assembly: 21.1490 CAM ASSY
## iProperties
Created: 2012-03
Part Number: 21.1490 CAM ASSY
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
