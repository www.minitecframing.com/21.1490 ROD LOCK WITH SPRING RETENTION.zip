# Autodesk Inventor assembly: 21.1486 SLAM LOCK
## iProperties
Created: 2012-03
Part Number: 21.1486 SLAM LOCK
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
